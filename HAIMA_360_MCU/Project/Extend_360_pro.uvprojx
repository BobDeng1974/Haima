# Keil uVision project Extend_360_pro.uvprojx, settings and files
target Extend_360_Pro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F302CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00006000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Extend_360_pro +hex
  AfterMake: mergebin.bat $K\ARM\ARMCC\bin\fromelf.exe Extend_360_Pro
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F30X,APP_AREA
  c include: ..\Inc;..\Inc\core;..\Lib;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8007800 size 0x18800
  memory RVCT9: RAM 0x20000000 size 0x400
  memory RVCT10: RAM 0x20000400 size 0x5c00
  group Startup
    ../Inc/core/: startup_stm32f30x.s
    ../App/: system_stm32f30x.c
  group Library
    ../Lib/: can.c gpio.c iflash.c misc.c timer.c arch.s usart.c adc.c can_net_layer.c diag_upgrade.c can_diag_protocol.c can_did.c can_dtc.c stm32f30x_adc.c stm32f30x_rcc.c nm.c upgrade.c
  group Application
    ../App/: message.c main.c function.c
software components: CMSIS:CORE 5.1.1
