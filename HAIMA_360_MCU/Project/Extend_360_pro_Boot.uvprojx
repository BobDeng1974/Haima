# Keil uVision project Extend_360_pro_Boot.uvprojx, settings and files
target Extend_360_Pro_Boot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F302CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00006000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Extend_360_pro_Boot +hex
  AfterMake: mergebin.bat $K\ARM\ARMCC\bin\fromelf.exe Extend_360_Pro_Boot
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: STM32F30X,APP_AREA
  c include: ..\Lib;..\Inc;..\Inc\core;..\Boot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7800
  memory RVCT9: RAM 0x20000000 size 0x400
  memory RVCT10: RAM 0x20000400 size 0x5c00
  group Startup
    ../Inc/core/: startup_stm32f30x.s
    ../Boot/: system_stm32f30x.c
  group library
    ../Lib/: gpio.c iflash.c misc.c usart.c arch.s diag_upgrade.c timer.c can.c can_net_layer.c can_diag_protocol.c can_did.c can_dtc.c nm.c adc.c stm32f30x_adc.c stm32f30x_rcc.c
  group Application
    ../Boot/: function.c main.c message.c
software components: CMSIS:CORE 5.1.1
